# IAR project battery_can_show.ewp, settings and files
configuration battery_can_show (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\UserLib; ..\UserLib\CANopenNode; ..\UserLib\CANopenNode\301; ..\UserLib\CANopenNode\303; ..\UserLib\CANopenNode\304; ..\UserLib\CANopenNode\305; ..\UserLib\CANopenNode\309; ..\UserLib\CANopenNode\extra; ..\UserLib\CANopenNode\storage; ..\UserLib\CANopenNode\extra; ..\UserLib\CANopenNode\storage; ..\UserLib\CANopenNode_STM32; ..\UserLib\cJSON; ..\UserLib\user_uart; ..\UserLib\nextionLCD; ..\UserLib\nextionLCD\driver; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\UserLib\serial_message
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: battery_can_show_matter.hex
  ILINK.IlinkOutputFile: battery_can_show.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Application/User/User_lib
    ../UserLib/: battery_manager.c battery_manager.h CANparser.c CANparser.h CANsend.c CANsend.h common.c common.h
  group Application/User/User_lib/cJson
    ../UserLib/cJSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h
  group Application/User/User_lib/nextion
    ../UserLib/nextionLCD/: ui_cells_alert_screen.c ui_cells_alert_screen.h ui_cells_screen.c ui_cells_screen.h ui_common.c ui_common.h ui_main_screen.c ui_main_screen.h ui_popup_screen.c ui_popup_screen.h ui_process.c ui_process.h ui_settings_screen.c ui_settings_screen.h ui_settings_screen_2.c ui_settings_screen_2.h ui_total_screen.c ui_total_screen.h
  group Application/User/User_lib/nextion/driver
    ../UserLib/nextionLCD/driver/: nextion.c nextion.h nextion_button.c nextion_button.h nextion_comboBox.c nextion_comboBox.h nextion_page.c nextion_page.h nextion_picture.c nextion_picture.h nextion_text.c nextion_text.h nextion_visible.c nextion_visible.h
  group Application/User/User_lib/serial_message
    ../UserLib/serial_message/: SerialMessage.c SerialMessage.h sys_command.c sys_command.h
  group Application/User/User_lib/user_uart
    ../UserLib/user_uart/: uart.c uart.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
